# IAR project Prj_K60N512_IAR.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK10DN512xxx10 Freescale MK10DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: COMPILER_IAR
  ICCARM.CCIncludePath2: ..\Project_Headers; ..\KinetisDrivers; ..\ExtraFunction; ..\Hardware_Interface; ..\Make_Decision; ..\Math; ..\Original_Process; ..\Platform; ..\SD_System; ..\Source; ..\System_Init
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Prj_K60N512_IAR.srec
  ILINK.IlinkOutputFile: Prj_K60N512_IAR.out
  ILINK.IlinkIcfFile: Linker Files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: StartUp_Kinetis
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCIncludePath2: ..\IAR Files\Project_Headers; ..\KinetisDrivers; ..\Source; ..\App\ExtraFunction; ..\App\SD_System; ..\App\LEDCtl; ..\App\ZLG7290; ..\App\OLED; ..\App\FTFL; ..\App\Platform; ..\App\HardwareInterface; ..\App\TypeAdapter; ..\uCOS_III\Cfg; ..\uCOS_III\Source; ..\uCOS_III\CortexM4
  group Linker Files
    Linker Files/: 512KB_Pflash.icf
  group Project/App
    ../App/: app.c app.h Common_Def.h
  group Project/App/ExtraFunction
    ../App/ExtraFunction/: ExtraFunction.c ExtraFunction.h
  group Project/App/FTFL
    ../App/FTFL/: FTFL.c FTFL.h
  group Project/App/HardwareInterface
    ../App/HardwareInterface/: HardwareOperation.c HardwareOperation.h Interrupt.c Interrupt.h
  group Project/App/LEDCtl
    ../App/LEDCtl/: LEDCtl.c LEDCtl.h LEDCtl_Ext.h
  group Project/App/OLED
    ../App/OLED/: OLED.c OLED.h
  group Project/App/Platform
    ../App/Platform/: Platform.c Platform.h
  group Project/App/SD_System
    ../App/SD_System/: fat32txt.c SD_driver.c SD_driver.h SD_System.h
  group Project/App/TypeAdapter
    ../App/TypeAdapter/: TypeAdapter.c TypeAdapter.h
  group Project/App/ZLG7290
    ../App/ZLG7290/: ZLG7290.c ZLG7290.h
  group Project/KinetisDrivers
    ../KinetisDrivers/: KinetisConfig.h KinetisOperate.c KinetisStart.c KinetisStartUp.s KinetisVectors.c KinetisVectors.h
  group Project/Source
    ../Sources/: main.c
  group Project/uCOS_III/Cfg
    ../uCOS_III/Cfg/: os_cfg.h os_cfg_app.h
  group Project/uCOS_III/CortexM4
    ../uCOS_III/CortexM4/: cpu_a.asm os_cpu.h os_cpu_a.asm os_cpu_c.c os_cpu_def.h
  group Project/uCOS_III/Source
    ../uCOS_III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tls.c os_tmr.c os_type.h os_var.c
